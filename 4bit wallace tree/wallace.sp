.OPTION ACCURATE
.LIB 'ALL_MOS.L' TT
*********************  INPUTS     ***********************
V_VDD 	VDD	0	DC	3.3

**************************sub*************************
.INCLUDE "AND2.SP"
.INCLUDE "FA_W.sp"

*****************************************************
V_A0      A0    0  PULSE  3.3 0  1P 1P 1NS 50NS
V_B0      B0    0  PULSE  3.3 0  1P 1P 1NS 50NS
V_A1      A1    0  PULSE  3.3 0  1P 1P 1NS 50NS
V_B1      B1    0  PULSE  3.3 0  1P 1P 1NS 50NS
V_A2      A2    0  PULSE  3.3 0  1P 1P 1NS 50NS
V_B2      B2    0  PULSE  3.3 0  1P 1P 1NS 50NS
V_A3      A3    0  PULSE  3.3 0  1P 1P 1NS 10NS
V_B3      B3    0  PULSE  3.3 0  1P 1P 1NS 10NS
V_A4      A4    0  PULSE  3.3 0  1P 1P 1NS 10NS
V_B4      B4    0  PULSE  3.3 0  1P 1P 1NS 10NS
V_A5      A5    0  PULSE  3.3 0  1P 1P 1NS 10NS
V_B5      B5    0  PULSE  3.3 0  1P 1P 1NS 10NS

**************************************************************
X1  A0 B0 P0  VDD AND2
X2  A1 B0 M1  VDD AND2
X3  A0 B1 M2  VDD AND2
X4  A2 B0 M3  VDD AND2
X5  A1 B1 M4  VDD AND2
X6  A0 B2 M5  VDD AND2
X7  A3 B0 M6  VDD AND2
X8  A2 B1 M7  VDD AND2
X9  A1 B2 M8  VDD AND2
X10  A0 B3 M9  VDD AND2
X11  A4 B0 M10  VDD AND2
X12  A3 B1 M11  VDD AND2
X13  A2 B2 M12  VDD AND2
X14  A1 B3 M13  VDD AND2
X15  A0 B4 M14  VDD AND2
X16  A4 B1 M15  VDD AND2
X17  A3 B2 M16  VDD AND2
X18  A2 B3 M17  VDD AND2
X19  A1 B4 M18  VDD AND2
X20  A4 B2 M19  VDD AND2
X21  A3 B3 M20  VDD AND2
X22  A2 B4 M21  VDD AND2
X23  A4 B3 M22  VDD AND2
X24  A3 B4 M23  VDD AND2
X25  A4 B4 M24  VDD AND2
**************************************
X26 M1 M2 GND P1 N1 VDD ADDER
X27 M3 M4 M5 N2 N3 VDD ADDER
X28 M6 M7 M8 N4 N5 VDD ADDER
X29 M10 M11 M12 N6 N7 VDD ADDER
X30 M15 M16 M17 N8 N9 VDD ADDER
X31 M19 M20 M21 N10 N11 VDD ADDER

X32 N1 N2 GND P2 R1 VDD ADDER
X33 N3 N4 M9 R2 R3 VDD ADDER
X34 N5 N6 M13 R4 R5 VDD ADDER
X35 N7 N8 M18 R6 R7 VDD ADDER
X36 N11 M22 M23 R8 R9 VDD ADDER

X37 R1 R2 GND  P3 S1 VDD ADDER
X38 R3 R4 M14 S2 S3 VDD ADDER
X39 N9 N10 R7 S4 S5 VDD ADDER

X40 S1 S2 GND P4 U1 VDD ADDER
X41 R5 R6 S3 U2 U3 VDD ADDER

X42 U1 U2 GND P5 U4 VDD ADDER
X43 U4 U3 S4 P6 U5 VDD ADDER
X44 U5 S5 R8 P7 U6 VDD ADDER
X45 U6 R9 M24 P8 P9 VDD ADDER

*********************************************

**********************************************************

.TRAN	 0.01P 	100N

.END
